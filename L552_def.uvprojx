# Keil uVision project L552_def.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x30000000,0x00040000) IROM(0x08000000,0x00080000) IROM2(0x0C000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: L552_def
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x40000
software components: CMSIS:CORE 5.4.0, Device:STM32Cube Framework:STM32CubeMX 1.1.0, Device:STM32Cube HAL:Common 1.0.4, Device:STM32Cube HAL:Cortex 1.0.4, Device:STM32Cube HAL:DMA 1.0.4, Device:STM32Cube HAL:Flash 1.0.4, Device:STM32Cube HAL:GPIO 1.0.4, Device:STM32Cube HAL:PWR 1.0.4, Device:STM32Cube HAL:RCC 1.0.4, Device:STM32Cube HAL:SPI 1.0.4, Device:Startup 1.0.3
