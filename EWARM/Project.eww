<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\default_L552.ewp</path>
  </project>
  <batchBuild />
</workspace>
