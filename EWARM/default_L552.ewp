# IAR project default_L552.ewp, settings and files
configuration default_L552 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L552ZE ST STM32L552ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32L552xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L5xx_HAL_Driver/Inc; ../Drivers/STM32L5xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L5xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: default_L552.hex
  ILINK.IlinkOutputFile: default_L552.out
  ILINK.IlinkIcfFile: stm32l552xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l552xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l5xx_it.c stm32l5xx_hal_msp.c
  group Drivers/STM32L5xx_HAL_Driver
    ../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_ll_utils.c stm32l5xx_ll_exti.c stm32l5xx_hal_adc.c stm32l5xx_hal_adc_ex.c stm32l5xx_hal.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_cortex.c stm32l5xx_hal_icache.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c stm32l5xx_hal_rtc.c stm32l5xx_hal_rtc_ex.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_ll_ucpd.c stm32l5xx_ll_gpio.c stm32l5xx_ll_dma.c stm32l5xx_hal_pcd.c stm32l5xx_hal_pcd_ex.c stm32l5xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l5xx.c
